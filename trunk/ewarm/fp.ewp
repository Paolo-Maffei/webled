# IAR project fp.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LPC1114 NXP LPC1114
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\freertos\; ..\freertos\include\; ..\dev\; ..\uip\; ..\lpc1114\inc; ..\app\telnetd; ..\app\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: fp.srec
  ILINK.IlinkOutputFile: fp.out
  ILINK.IlinkIcfFile: ..\lpc1114\icf\LPC1114_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../app/: FreeRTOSConfig.h led7_task.c led7_task.h main.c main.h uip_task.c uip_task.h
  group app/telnetd
    ../app/telnetd/: memb.c memb.h shell.c shell.h telnetd.c telnetd.h
  group dev
    ../dev/: enc28j60.c enc28j60.h led7.c led7.h spi.c spi.h
  group freertos
    ../freertos/: heap_1.c list.c port.c portasm.s portmacro.h queue.c tasks.c
  group freertos/include
    ../freertos/include/: croutine.h FreeRTOS.h list.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group lpc1114/inc
    ../lpc1114/inc/: clkconfig.h core_cm0.h gpio.h LPC11xx.h power_profiles.h system_LPC11xx.h timer16.h timer32.h type.h uart.h
  group lpc1114/src
    ../lpc1114/src/: clkconfig.c core_cm0.c cstartup_M.s gpio.c system_LPC11xx.c timer16.c timer32.c uart.c
  group uip
    ../uip/: clock.h clock_arch.c clock_arch.h uip.c uip.h uip_arch.c uip_arch.h uip_arp.c uip_arp.h uip_conf.h uip_timer.c uip_timer.h uipopt.h
